# IAR project cl_p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4078 NXP LPC4078
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe191, Pe009,Pa093,Pe068,Pe550
  ICCARM.CCIncludePath2: $PROJ_DIR$; LPC\; SRC\; OBJ\; SRC\INIT\; SRC\TEST\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: cl_p.srec
  ILINK.IlinkOutputFile: cl_p.out
  ILINK.IlinkIcfFile: lpc\MemoryMap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    lpc/: MemoryMap.icf startup_LPC177x_8x.s
  group LPC
    lpc/: fpu_init.c system_LPC177x.c
  group SRC
    SRC/: _main.cpp adc.cpp can.cpp controllerDMA.cpp crc16.cpp dac.cpp din_cpu.cpp dout_cpu.cpp i_adc.cpp rem_osc.cpp rtc.cpp settings_eep.cpp spi_ports.cpp uart.cpp
  group SRC/INIT
    SRC/INIT/: emac.cpp emc.cpp Ports_init.cpp SDCard_init.cpp Timers_init.cpp
  group SRC/TESTS
    SRC/TEST/: Compare.cpp Puls.cpp terminal.cpp test_eth.cpp Tests.cpp
