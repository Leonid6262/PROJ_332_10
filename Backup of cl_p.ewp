# IAR project Backup of cl_p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4078 NXP LPC4078
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe191, Pe009,Pa093,Pe068,Pe550
  ICCARM.CCIncludePath2: $PROJ_DIR$; lpc\; SRC\; OBJ\; SRC\INIT\; SRC\TESTS\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: cl_p.out
  ILINK.IlinkIcfFile: lpc\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    lpc/: ldscript_irom_iar.icf
    SRC/INIT/: startup_LPC177x_8x.s
  group INIT
    SRC/INIT/: adc_drv.c dma_init.c emc.c spi_drv.c Timers_init.c
    lpc/: lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_gpdma.c lpc177x_8x_mcpwm.c lpc177x_8x_pinsel.c system_LPC177x.c
  group SRC
    SRC/: Din_cpu.c Dout_cpu.c main.cpp RWspi.c
